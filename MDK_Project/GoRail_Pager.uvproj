# Keil uVision project GoRail_Pager.uvproj, settings and files
target GoRail_Pager (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GoRail_Pager
  c flags: Optim=4
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,RADIO_DEBUG_MSG_ON,POCSAG_DEBUG_MSG_ON
  c misc: --c99
  c include: ..\App_User;..\Sys_Utils;..\Sys_Utils\FatFS;..\Hardware;..\FirmwareLib;..\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App/User
    ../App_User/: GoRail_Pager.h main.c ComPort_Utility.c HMI_Display_Utils.c Radio_Utils.c Logging_Utils.c
  group Sys/Utils
    ../Sys_Utils/: bit.h delay.c POCSAG_ParseLBJ.c Setting_Utils.c
  group Sys/Utils/FatFS
    ../Sys_Utils/FatFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group Hardware
    ../Hardware/: Hardware.h HW_GPIO.c HW_IIC_SoftSimulate.c HW_OLED_Font.c HW_RADIO_CC1101.c HW_SSD1306_OLED.c HW_TIM.c HW_USART.c HW_EEPROM_24CXX.c HW_RTC_DS3231.c HW_SPI_SDCard.c
  group FirmwareLib
    ../FirmwareLib/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_md.s stm32f10x_conf.h system_stm32f10x.c
  group Documents
    ../: README.md
